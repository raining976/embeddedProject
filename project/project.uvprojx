# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_MD,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\Fwlib\CMSIS\CM3\CoreSupport;..\Fwlib\CMSIS\Documentation;..\Fwlib\STM32F10x_StdPeriph_Driver\inc;..\Fwlib\STM32F10x_StdPeriph_Driver\src;..\Fwlib;..\Fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\Fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: app_main.c app_bluetooth.h app_bluetooth.c app_dht11.h app_dht11.c app.h app.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_gpio.h bsp_time.c bsp_time.h bsp_breathe.c bsp_breathe.h bsp_usart.c bsp_usart.h bluetooth.c typedef.h bluetooth.h bsp_motor.c bsp_motor.h myutils.c myutils.h bsp_ic.h bsp_ic.c systick.c systick.h taskscheduler.c taskscheduler.h dht11.h dht11.c fml_oled.c fml_oled.h OLED_Font.h
  group Fwlib
    ../Fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Fwlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Fwlib/CMSIS/CM3/CoreSupport/: core_cm3.h
    ../Fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.h
  group cmsis
    ../Fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Fwlib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group startup
    ../Fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
